# Keil uVision project pid.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pid
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group source
    ./source/: adc.c gpio.c interrupt.c LeNguyenKhanhLam.c main.c spi.c sysTick.c timer.c uart.c
    ./: pid.c
  group include
    ./include/: adc.h gpio.h interrupt.h LeNguyenKhanhLam.h RCC.h spi.h sysTick.h timer.h uart.h
    ./: pid.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
